# Keil uVision project Engineer.uvprojx, settings and files
target Standrad (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Engineer +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\Libraries\CMSIS\Device\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\User\Hardware\LED;..\User\FreeRTOS\include;..\User\FreeRTOS\portable\RVDS\ARM_CM4F;..\User\APP\FreeRTOS_middleware;..\User\APP\remote_control;..\User\Hardware\buzzer;..\User\Hardware\delay;..\User\Hardware\flash;..\User\Hardware\laser;..\User\Hardware\rc;..\User\Hardware\rng;..\User\Hardware\timer;..\User\APP\detect_task;..\User\APP\start_task;..\User\Hardware\can;..\User\Hardware\usart;..\User\IMU\IMU_ONBOARD;..\User\APP\INS_task;..\User\APP\oscillography_task;..\User\USER_LIB;..\User\APP\robot;..\User\Hardware\motor;..\User\APP\timer_send_task;..\User\APP\chassis_task;..\User\Hardware\sys;..\User\Hardware\power;..\User\Hardware\spi;..\User\APP\basic_task;..\User\APP\grab_task;..\User\Hardware\sensor;..\User\Hardware\servo;..\User\Hardware\valve;..\User\IMU\IMU_OUT;..\User\Hardware\mf9025;..\User\Hardware\messageBoard_B
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../User/APP/robot/: robot.c
    ../User/APP/start_task/: start_task.c
    ../User/APP/INS_task/: INS_task.c
    ../User/APP/chassis_task/: chassis_task.c chassis_behaviour.c
    ../User/APP/grab_task/: grab_task.c grab_behaviour.c
    ../User/APP/basic_task/: basic_task.c
    ../User/APP/detect_task/: detect_task.c
    ../User/APP/remote_control/: remote_control.c
    ../User/APP/oscillography_task/: oscillography.c
    ../User/APP/FreeRTOS_middleware/: FreeRTOS_middleware.c
    ../User/APP/timer_send_task/: timer_send_task.c
    ../User/Hardware/mf9025/: mf9025.c
  group USER
    ../User/: main.c stm32f4xx_it.c
  group IMU
    ../User/IMU/IMU_ONBOARD/: AHRS.lib IMU_onBoard.c
    ../User/IMU/IMU_OUT/: IMU_ext.c
  group USER_LIB
    ../User/USER_LIB/: arm_cortexM4lf_math.lib kalman.c kalman_filter.c user_lib.c arm_mat_add_f32.c arm_mat_cmplx_mult_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_scale_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c pid.c
  group HARDWARE
    ../User/Hardware/laser/: laser.c
    ../User/Hardware/LED/: led.c
    ../User/Hardware/buzzer/: buzzer.c
    ../User/Hardware/flash/: flash.c
    ../User/Hardware/rc/: rc.c
    ../User/Hardware/rng/: rng.c
    ../User/Hardware/timer/: timer.c
    ../User/Hardware/can/: can.c
    ../User/Hardware/usart/: usart3_dma.c usart2.c usart6.c uart7.c
    ../User/Hardware/motor/: motor.c
    ../User/Hardware/sys/: sys.c
    ../User/Hardware/power/: power.c
    ../User/Hardware/spi/: spi5.c
    ../User/Hardware/sensor/: sensor.c
    ../User/Hardware/servo/: servo.c
    ../User/Hardware/valve/: valve.c
    ../User/Hardware/delay/: delay.c
    ../User/Hardware/messageBoard_B/: messageBoard_B.c
  group FreeRTOS_PORTABLE
    ../User/FreeRTOS/portable/MemMang/: heap_4.c
    ../User/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS_CORE
    ../User/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_iwdg.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_rng.c
  group CMSIS
    ../Libraries/CMSIS/Device/Source/: system_stm32f4xx.c
  group STARTUP
    ../Libraries/CMSIS/Device/Source/: startup_stm32f427xx.s
  group README
    ../Doc/: readme.txt
